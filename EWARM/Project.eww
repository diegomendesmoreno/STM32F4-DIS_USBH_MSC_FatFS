<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F4-DIS_USBH_MSC_FatFS.ewp</path>
  </project>
  <batchBuild />
</workspace>
